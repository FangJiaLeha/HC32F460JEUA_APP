# Keil uVision project project.uvprojx, settings and files
target HC32F460JEUA_app (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F460.1.0.7
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pallet_check_hc32f460jeua_app +hex
  AfterMake: "Post Universe Chassis.bat"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HC32F460, RT_USING_ARM_LIBC, USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: .;..\rtos\include;..\soc\soc_hc32f460xxxx\drivers;..\soc\soc_hc32f460xxxx\libraries\CMSIS;..\soc\soc_hc32f460xxxx\libraries\driver\inc;..\soc\soc_hc32f460xxxx\libraries\mcu\common;..\bsp;..\bsp\pcf8574;..\bsp\tlc59108;..\bsp\vl53l0x_dev_lib;..\bsp\ws2812;..\bsp\drivers\include;..\rtos\components\drivers\include;..\rtos\components\drivers\include;..\rtos\components\drivers\include;..\rtos\components\drivers\include;..\rtos\components\drivers\include;..\rtos\components\drivers\include;..\bsp\pallet_check_board;..\bsp\vl53l0x_dev_lib\core\inc;..\bsp\vl53l0x_dev_lib\platform\inc;..\pkgs\led_ctrl_frame;..\src;..\src\protocol;.;..\src\tasks;.;..\rtos\libcpu\arm\cortex-m4;..\rtos\libcpu\arm\common;..\rtos\components\dfs\include;..\rtos\components\dfs\filesystems\devfs;..\rtos\components\dfs\filesystems\elmfat;..\rtos\components\drivers\sensors;..\rtos\components\drivers\include;..\rtos\components\finsh;..\rtos\components\libc\compilers\armlibc;..\rtos\components\libc\compilers\common;..\rtos\components\utilities\ulog;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x70000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8080 size 0x2ef80
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group User
    ../user/: user_config.h iap_config.c iap.c
  group Kernel
    ../rtos/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Drivers
    ../soc/soc_hc32f460xxxx/drivers/: board.c drv_usart.c drv_onewire.c drv_pwm.c drv_can.c drv_i2c.c drv_gpio.c drv_wdt.c
  group HC32_Lib
    ../soc/soc_hc32f460xxxx/libraries/driver/src/: hc32f460_can.c hc32f460_clk.c hc32f460_dmac.c hc32f460_efm.c hc32f460_gpio.c hc32f460_interrupts.c hc32f460_pwc.c hc32f460_sram.c hc32f460_timera.c hc32f460_usart.c hc32f460_utility.c hc32f460_wdt.c hc32f460_rmu.c
    ../soc/soc_hc32f460xxxx/libraries/mcu/common/: system_hc32f460.c
    ../soc/soc_hc32f460xxxx/libraries/mcu/MDK/: startup_hc32f460.s
  group bsp
    ../bsp/pcf8574/: pcf8574.c
    ../bsp/tlc59108/: TLC59108.c
    ../bsp/vl53l0x_dev_lib/: vl53l0x_dev.c
    ../bsp/ws2812/: ws2812.c
  group DeviceDrivers
    ../bsp/drivers/misc/: rt_drv_onewire.c
    ../rtos/components/drivers/can/: can.c
    ../rtos/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../rtos/components/drivers/misc/: pin.c rt_drv_pwm.c
    ../rtos/components/drivers/serial/: serial.c
    ../rtos/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../rtos/components/drivers/watchdog/: watchdog.c
  group bsp_pallet_check
    ../bsp/pallet_check_board/: pallet_led_bar.c heartbeat_led.c
  group vl53l0x_dev_lib
    ../bsp/vl53l0x_dev_lib/core/src/: vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_api.c
  group led_ctrl_frame
    ../pkgs/led_ctrl_frame/: led_frame.c
  group Applications
    ../src/: main.c
  group app_led_bar
    ../src/led_bar/: led_bar.c
  group app_protocol
    ../src/protocol/: protocol_main.c
  group app_sensors
    ../src/sensors/: pallet_detect.c sensors.c
  group tasks
    ../src/tasks/: joker.c
  group CORTEX-M4
    ../rtos/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../rtos/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../rtos/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../rtos/components/dfs/filesystems/devfs/: devfs.c
    ../rtos/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group Sensors
    ../rtos/components/drivers/sensors/: sensor.c sensor_cmd.c
  group finsh
    ../rtos/components/finsh/: shell.c cmd.c msh.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../rtos/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    ../rtos/components/libc/compilers/common/: time.c
  group Utilities
    ../rtos/components/utilities/ulog/: ulog.c
    ../rtos/components/utilities/ulog/backend/: console_be.c
